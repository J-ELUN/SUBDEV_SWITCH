# Keil uVision project Project.uvproj, settings and files
target STM32L053C8_Discovery (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: STM32L053C8_Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0538_DISCO,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32L0538-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L053C8_Discovery
    ../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
  group Example/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
